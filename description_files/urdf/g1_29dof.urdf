Commit message: fixed auto_enable + lidar orientation

File: description_files/urdf/g1_29dof.urdf (robot description, URDF)
Before this commit: robot g1_29dof_rev_1_0, 57 links, 56 joints
Joints:
- joint livox_joint: origin xyz=0.0 0.0 0.0 rpy=3.141561 0 0 -> xyz=0.0 0.0 0.0 rpy=0 0 0
